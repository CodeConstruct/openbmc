FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:witherspoon-microwatt = " file://button1.patch"
